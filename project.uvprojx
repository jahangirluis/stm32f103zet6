# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xE
  c include: .;application;..\..\arch\arm\armv7m\include;board;board\CubeMX_Config\Inc;board\ports;board\packages;..\..\common\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\drivers;..\..\drivers\bus;..\..\drivers\can;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\spi\sfud\inc;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\graphic;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\..\drivers\hal\st\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Include;..\..\drivers\infrared;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\position;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\net_pos;..\..\drivers\sensors;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/: arch_atomic.c arch_exception.c arch_interrupt.c arch_misc.c arch_task.c
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32f1xx_hal_msp.c stm32f1xx_it_bsp.c system_stm32f1xx.c
    board/startup/: startup_stm32f103xe_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/backend/: console_backend.c
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/syslog/: syslog.c
  group drivers
    ../../drivers/misc/: adc.c dac.c pulse_encoder.c push_button.c pwm.c
    ../../drivers/i2c/: at24cxx.c i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/can/: can.c
    ../../drivers/timer/: clockevent.c clocksource.c clocksource_cortexm.c hrtimer.c timer.c
    ../../drivers/console/: console.c
    ../../drivers/: device.c driver.c
    ../../drivers/dma/: dma.c
    ../../drivers/fal/: fal.c fal_block.c fal_mtd.c fal_part.c
    ../../drivers/spi/flash/: fal_flash_sfud_port.c flash_spi.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../drivers/watchdog/: watchdog.c
  group graphic
    ../../drivers/graphic/: atk_tflcd9341.c graphic.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_adc.c drv_can.c drv_common.c drv_dac.c drv_gpio.c drv_hwtimer.c drv_iwdg.c drv_pulse_encoder.c drv_pwm.c drv_rtc.c drv_spi.c drv_sram.c drv_usart.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_f1.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_spi.c
  group infrared
    ../../drivers/infrared/: infrared.c remote_control_atk.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group sensors
    ../../drivers/sensors/: photo_diode.c sensor.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
